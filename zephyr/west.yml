## zephyr/west.yml
```yaml
manifest:
  projects:
    - name: zmk-pmw3610-driver
      url: https://github.com/badjeff/zmk-pmw3610-driver
      revision: main
```
